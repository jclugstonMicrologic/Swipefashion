# IAR project AMC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4xx; DEBUG_MODE; GATEWAY
  ICCARM.CCIncludePath2: C:\software\FreeRTOS\include; C:\software\STM32L4xx_StdPeriph_Driver\inc; C:\software\STM32F4xx_StdPeriph_Driver\inc; C:\software\FreeRTOS\Source\portable\IAR\ARM_CM4F; C:\Software\ApparelSizeLtd\AMC\includes\core; C:\Software\ApparelSizeLtd\AMC\includes; C:\software\common\includes
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: C:\Software\ApparelSizeLtd\AMC\includes
  OBJCOPY.OOCOutputFile: AMC_v0.xx.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\Software\ApparelSizeLtd\AMC\stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: C:\Software\STM32L4_SPL\stm32l476xx_flash.icf
  group (top)
    ./: readme.txt
  group application
    source/: AdcFd.c adcHi.c AmcConfig.c BluetoothMachine.c crc.c dfu.c flash_if.c gpioHi.c main.c MainControlTask.c PCMachine.c PowerManagement.c PressureTdrHi.c pwmHi.c rtcHi.c SciAsciiMachine.c SciBinaryMachine.c SciFd.c sciHi.c solenoidHi.c spiHi.c stm32f4xx_it.c sysTimers.c wtdHi.c
  group FreeRTOS
    ../../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/portable
    ../../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group STM32_StdPeripherals
    ../../STM32L4xx_StdPeriph_Driver/src/: misc.c stm32l4xx_adc.c stm32l4xx_dbgmcu.c stm32l4xx_exti.c stm32l4xx_flash.c stm32l4xx_gpio.c stm32l4xx_iwdg.c stm32l4xx_pwr.c stm32l4xx_rcc.c stm32l4xx_rtc.c stm32l4xx_spi.c stm32l4xx_syscfg.c stm32l4xx_tim.c stm32l4xx_usart.c stm32l4xx_wwdg.c
  group system
    ./: startup_stm32l476xx.s system_stm32l4xx.c
